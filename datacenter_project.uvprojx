# Keil uVision project datacenter_project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: datacenter_project +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Oz
  c include: .;.\FatFs;C:\Users\daksh\AppData\Local\Arm\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include;C:\Users\daksh\AppData\Local\Arm\Packs\Keil\STM32F4xx_DFP\2.17.1\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  asm misc: -Oz
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: code.c
  group Drivers
    ./: sd_spi.c
  group FatFs
    ./FatFs/: diskio.c ff.c ffunicode.c
  group Device
    ./RTE/Device/STM32F411CEUx/: startup_stm32f411xe.s system_stm32f4xx.c
